# IAR project ZbNode.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; HEAP_SIZE=5500
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../include; ../../../os/inc; ../../../arch/CC253x/inc; ../../../common/inc; ../../../drivers/CC253x/inc; ../../../net/inc; ../App
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: N0DEBUG; INCLUDE_PA=2592; chip=2530; HEAP_SIZE=4000
  ICC8051.CCIncludePath2: ../../../include; ../../../os/inc; ../../../arch/CC253x/inc; ../../../common/inc; ../../../drivers/CC253x/inc; ../../../drivers/inc; ../../../net/inc; ../App
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: NDEBUG
  postbuild: .\fl_merge.exe
  XLINK.XclFile: ../../../Tools/ota.xcl
  group application
    ../App/: Application.c attribute.c board.c netMngr.c nvram.c sysTask.c upgrade.c
  group arch
    ../../../arch/CC253x/src/: chipcon_cstartup.s51 hal_startup.c startup.c
  group common
    ../../../common/src/: crc.c list.c ush_cmd.c ushell.c
  group drivers
    ../../../drivers/src/: att7053bu.c gpioSpi.c
    ../../../drivers/CC253x/src/: hal_clock.c hal_flash.c hal_mcu.c hal_pwm.c hal_rf.c hal_time.c hal_uart.c
  group nbiot
    ../../../nbiot/: BC95.c
  group net
    ../../../net/src/: sMac.c sNwk.c
  group os
    ../../../os/src/: BosMem.c kernel.c sysTimer.c
  group tools
    ../../../Tools/: ota.xcl
